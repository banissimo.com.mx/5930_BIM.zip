Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0000
Time: 2021-09-02T12:04:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.4.1.0 - Alternative Benutzeroberfläche 19.4.1.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 02 12:04:29 2021 * Host: PC-Revit * Database: C:\Users\revit\AppData\Local\Temp\{A1676466-669F-4DBE-B315-D2E28EC8137F}\ifc * Database version: 5507 * Database creation date: Thu Sep 02 12:04:28 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 02 12:04:28 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 02 12:04:28 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0000
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 53, 27, 52, 270202; RefLongitude: 9, 59, 10, 609588; RefElevation: 0 mm

# IfcBuilding, Bette Objekte
LongName: Bette Objekte
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Ebene:CAx_3 mm_GEbene, Platzierungsebene
In: Bette Objekte
LongName: Platzierungsebene; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Platzierungsebene; sets with these values: 2

# IfcDistributionPort, Port_17008711
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: BE3B_Ultra_700-1000_25_01:Bette_Ultra 900x900x25, BE3B_Ultra_700-1000_25_01:Bette_Ultra 900x900x25:17008711
In: Platzierungsebene
Type - PredefinedType: SHOWER; Material: <Unnamed>, Lampe
Type - Pset_DistributionFlowElementCommon - Reference: Bette_Ultra 900x900x25
Type - Pset_QuantityTakeOff - Reference: Bette_Ultra 900x900x25
Type - Bette IFC Informationen DE - 00_Bette Bette Revision: 001_01.01.2021; 03_Bette Bauteiltyp: Dusche; 04_Bette Laenge: 900 mm; 05_Bette Breite: 900 mm; 06_Bette Hoehe: 25 mm; 07_Bette Bestellnummer: 5930; 10_Bette Randhoehe: 30 mm; 11_Bette www: https://www.my-bette.com/de/produkte/duschwannen/detail?p=Ultra%20700-900%20mm; 12_Bette Datenblatt: https://content.my-bette.com/produkt_downloads/BetteUltra-700-900-mm-292644/2021-Datasheet-BetteUltra-700-900-DE.pdf
Type - Bette IFC Informationen EN - 00_Bette Bette Index: 001_01.01.2021; 03_Bette Component type: shower; 04_Bette Length millimeters: 900 mm; 05_Bette Width millimeters: 900 mm; 06_Bette Height millimeters: 25 mm; 07_Bette Order number: 5930; 10_Bette Rim hight: 30 mm; 11_Bette www: https://www.my-bette.com/de/produkte/duschwannen/detail?p=Ultra%20700-900%20mm; 12_Bette Data sheet with dimensions: https://content.my-bette.com/produkt_downloads/BetteUltra-700-900-mm-292644/2021-Datasheet-BetteUltra-700-900-DE.pdf
Material: Lampe, <Unnamed> (6)
Pset_DistributionFlowElementCommon - sets with these values: 2
Bette IFC Informationen DE - 01_Bette Hersteller: Bette; 02_Bette Typ: Typ5930; 08_Bette Gewicht: 18.8 kg
Bette IFC Informationen EN - 01_Bette Manufacturer: Bette; 02_Bette Type: Typ5930; 08_Bette Weight kilogram: 18.8 kg
